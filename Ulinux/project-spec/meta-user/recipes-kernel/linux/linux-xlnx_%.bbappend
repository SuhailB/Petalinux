SRC_URI += "file://user_2018-11-18-02-28-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

